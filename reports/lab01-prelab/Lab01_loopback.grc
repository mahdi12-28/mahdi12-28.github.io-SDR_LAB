options:
  parameters:
    generate_options: qt_gui
    id: Lab01_loopback
    output_language: python
    title: Lab01_loopback
  states: {}

blocks:
- name: f_tune
  id: variable
  parameters:
    value: int(fc + lo_shift)
  states: {}
- name: f_tx
  id: variable_qtgui_range
  parameters:
    label: f_tx
    start: '-1e6'
    step: 50e3
    stop: 1e6
    value: 250e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 325e6
    step: 16e6
    stop: 3.8e9
    value: 945e6
    widget: counter
  states: {}
- name: lo_shift
  id: variable_qtgui_range
  parameters:
    label: lo_shift
    start: '-500e3'
    step: 10e3
    stop: 500e3
    value: '0'
    widget: counter
  states: {}
- name: rec
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Record I/Q
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rec_sec
  id: variable
  parameters:
    value: min(4.0, 80e6/(8*samp_rate))
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    start: '0'
    step: '1'
    stop: '10'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: samp_rate
    label0: 2.6 MS/s
    label1: 5 MS/s
    label2: 10 MS/s
    label3: 20 MS/s
    num_opts: '4'
    option0: '2600000'
    option1: '5000000'
    option2: '10000000'
    option3: '20000000'
    type: int
    value: '2600000'
    widget: radio_buttons
  states: {}
- name: team
  id: variable
  parameters:
    value: '"Ghalami_Momeni"'
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    label: tx_att
    start: '40'
    step: '1'
    stop: '89'
    value: '69'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: f_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import math
      import os
      import time

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Record raw complex64 IQ samples on a record-checkbox rising edge."""

          def __init__(self, team='Team-00', lab=1, fc=100e6, fs=2.6e6,
                       gain=0.0, record=False, max_seconds=5.0, folder='.'):
              gr.sync_block.__init__(
                  self,
                  name='SDR Lab IQ Recorder',
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # Matching names let GRC update these values at runtime.
              self.team = team
              self.lab = lab
              self.fc = fc
              self.fs = fs
              self.gain = gain
              self.record = record
              self.max_seconds = max_seconds
              self.folder = folder

              # No files or folders are created while GRC inspects the block.
              self._state = 'IDLE'
              self._file = None
              self._settings = None
              self._written = 0
              self._limit = 0

          def _begin(self, settings):
              fc, fs, gain = settings
              duration = float(self.max_seconds)
              if not all(math.isfinite(v) for v in settings):
                  raise ValueError('fc, fs and gain must be finite numbers')
              if fs <= 0 or not math.isfinite(duration) or duration < 0:
                  raise ValueError('fs must be positive; max_seconds must be finite and nonnegative')

              self._limit = math.floor(duration * fs)
              stamp = time.strftime('%Y%m%dT%H%M%S')
              filename = (
                  f'{self.team}_lab{int(self.lab):02d}_'
                  f'{int(round(fc))}_{int(round(fs))}_{gain:.1f}_{stamp}.cf32'
              )
              folder = os.path.expanduser(os.fspath(self.folder))
              os.makedirs(folder, exist_ok=True)
              path = os.path.join(folder, filename)
              # Exclusive creation protects an existing recording with the same name.
              self._file = open(path, 'xb')
              self._settings = settings
              self._written = 0
              self._state = 'RECORDING'
              print(f'[REC] start {filename}', flush=True)

          def _finish(self, reason, next_state):
              if self._file is not None:
                  self._file.close()
                  self._file = None
                  seconds = self._written / self._settings[1]
                  print(
                      f'[REC] stop {self._written} samples = '
                      f'{seconds:.2f} s ({reason})',
                      flush=True
                  )
              self._state = next_state

          def work(self, input_items, output_items):
              samples = input_items[0]
              requested = bool(self.record)
              settings = (float(self.fc), float(self.fs), float(self.gain))

              if not requested:
                  self._finish('record unchecked', 'IDLE')
                  return len(samples)

              if self._state == 'WAIT':
                  return len(samples)

              if self._state == 'IDLE':
                  self._begin(settings)
              elif settings != self._settings:
                  self._finish('fc/fs/gain changed', 'WAIT')
                  return len(samples)

              # Trim the last chunk to reach the exact sample limit.
              count = min(len(samples), self._limit - self._written)
              if count > 0:
                  np.asarray(samples[:count], dtype=np.complex64).tofile(self._file)
                  self._written += count

              if self._written == self._limit:
                  self._finish('max_seconds reached', 'WAIT')

              # A sink consumes the entire input, including samples not recorded.
              return len(samples)

          def stop(self):
              self._finish('flowgraph stopped', 'IDLE')
              return True
    fc: f_tune
    folder: '"recordings"'
    fs: samp_rate
    gain: rf_gain
    lab: '1'
    max_seconds: rec_sec
    record: rec
    team: team
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: int(fc)
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: f_tune
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: sc16
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_tune
    fftsize: '1024'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_tune
    fftsize: '1024'
    grid: 'True'
    int_max: '-20'
    int_min: '-110'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
